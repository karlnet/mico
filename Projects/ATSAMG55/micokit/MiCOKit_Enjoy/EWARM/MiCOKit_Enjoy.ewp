# IAR project MiCOKit_Enjoy.ewp, settings and files
configuration MiCOKit-G55 (ARM)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel ATSAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; __SAMG55J19__; ARM_MATH_CM4=true; BOARD=USER_BOARD; MICOKIT_G55
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\Demos\micokit\MiCOKit_Enjoy; ..\..\..\..\..\include; ..\..\..\..\..\MICO; ..\..\..\..\..\Board\MiCOKit-G55; ..\..\..\..\..\Platform\include; ..\..\..\..\..\Platform\Cortex-M4; ..\..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\..\Platform\MCU; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\rtt; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\supc; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\matrix; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\ioport; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include\instance; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\preprocessor; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\header_files; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\boards; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi; ..\..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc; ..\..\..\..\..\libraries\utilities; ..\..\..\..\..\mico\system; ..\..\..\..\..\Demos\micokit\MiCOKit_Enjoy\AppFramework; ..\..\..\..\..\Demos\micokit\MiCOKit_Enjoy\User; ..\..\..\..\..\include\FogCloud; ..\..\..\..\..\Platform\Drivers; ..\..\..\..\..\Platform\Drivers\display; ..\..\..\..\..\Platform\Drivers\rgb_led; ..\..\..\..\..\Platform\Drivers\sensor; D:\github\mico_on_gitlab\Platform\Drivers; ..\..\..\..\..\MICO\security
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MiCOKit_Enjoy.bin
  ILINK.IlinkOutputFile: MiCOKit_Enjoy.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Board\MiCOKit-G55\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/AppFramework
    ../../../../../Demos/micokit/MiCOKit_Enjoy/AppFramework/: fogCloud.c fogCloud.h fogcloud_msg_dispatch.c fogcloud_msg_dispatch.h MiCOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MiCOFogCloudDef.h properties.c properties.h
  group Application/User
    ../../../../../Demos/micokit/MiCOKit_Enjoy/User/: mico_config.h user_config.h user_main.c user_properties.c user_properties.h user_uart.c user_uart.h
  group Board/MiCOKit-G55
    ../../../../../Board/MiCOKit-G55/: platform.c platform.h platform_config.h
  group include
    ../../../../../include/: Debug.h MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/fogcloud
    ../../../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group include/MicoDriver
    ../../../../../include/MicoDrivers/: MICODriverAdc.h MICODriverGpio.h MICODriverI2c.h MICODriverMFiAuth.h MICODriverNanoSecond.h MICODriverPwm.h MICODriverRng.h MICODriverRtc.h MICODriverSpi.h MICODriverUART.h MICODriverWdg.h
  group libraries/protocols/fogcloud
    ../../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a
  group libraries/utilities
    ../../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group mico/core
    ../../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_spi.a
  group mico/system
    ../../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../../MICO/system/command_console/: mico_cli.c
    ../../../../../MICO/system/mdns/: mico_mdns.c
    ../../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
    ../../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
    ../../../../../MICO/system/tftp_ota/: tftp_ota.c tftpc.o
  group Platform/Cortex-M4
    ../../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../../Platform/Drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../../Platform/Drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../../Platform/Drivers/keypad/gpio_button/: button.c button.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../../Platform/Drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../../Platform/Drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../../Platform/Drivers/MiCOKit_EXT/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../../Platform/Drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../../Platform/Drivers/sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/SPI Flash
    ../../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/STM32_USB_Host_Library/Class/MSC
    ../../../../../Platform/Drivers/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Platform/Drivers/STM32_USB_Host_Library/Core
    ../../../../../Platform/Drivers/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Platform/EWARM
    ../../../../../Platform/EWARM/: close.c lseek.c remove.c Retarget.c
  group Platform/MCU
    ../../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/ATSAMG55
    ../../../../../Platform/MCU/ATSAMG55/: platform_init.c
  group Platform/MCU/ATSAMG55/EWARM
    ../../../../../Platform/MCU/ATSAMG55/EWARM/: startup_ATSAMG55_EWARM.s
  group Platform/MCU/ATSAMG55/Peripherals
    ../../../../../Platform/MCU/ATSAMG55/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/clock
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/clock/samg/: sysclk.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/services/sleepmgr
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/services/sleepmgr/sam/: sleepmgr.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/common/utils/interrupt
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/common/utils/interrupt/: interrupt_sam_nvic.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/adc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/adc/: adc2.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/efc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/efc/: efc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/flexcom/: flexcom.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/matrix
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/matrix/: matrix.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pdc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pdc/: pdc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pio
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pio/: pio.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/pmc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/pmc/: pmc.c sleep.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/rtt
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/rtt/: rtt.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/spi
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/spi/: spi.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/supc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/supc/: supc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/twi
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/twi/: twi.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/usart
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/usart/: usart.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/drivers/wdt
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/drivers/wdt/: wdt.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/services/flash_efc
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/services/flash_efc/: flash_efc.c
  group Platform/MCU/ATSAMG55/Peripherals/Libraries/asf-3.22.0/sam/utils/cmsis
    ../../../../../Platform/MCU/ATSAMG55/peripherals/Libraries/asf-3.22.0/sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group Platform/MCU/ATSAMG55/wlan_bus_driver
    ../../../../../Platform/MCU/ATSAMG55/wlan_bus_driver/: wlan_bus_spi.c wlan_platform.c
