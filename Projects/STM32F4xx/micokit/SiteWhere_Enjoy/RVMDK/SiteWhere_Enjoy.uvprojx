# Keil uVision project SiteWhere_Enjoy.uvprojx, settings and files
target MiCOKit-3288 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SiteWhere_Enjoy.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG HSE_VALUE=16000000 MICOKIT_3288
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\AppFramework;..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\User;..\..\..\..\..\include;..\..\..\..\..\MICO\system;..\..\..\..\..\libraries\utilities;..\..\..\..\..\MICO\security;..\..\..\..\..\Board\MiCOKit-3288;..\..\..\..\..\Platform\include;..\..\..\..\..\Platform\Cortex-M4;..\..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\..\Platform\Drivers\MiCOKit_EXT;..\..\..\..\..\include\FogCloud;..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\SiteWhere;..\..\..\..\..\Platform\Drivers;..\..\..\..\..\Platform\Drivers\display;..\..\..\..\..\Platform\Drivers\rgb_led;..\..\..\..\..\Platform\Drivers\sensor
  memory RVCT4: ROM 0x800c000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Board/MiCOKit-3288
    ../../../../../Board/MiCOKit-3288/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3165
    ../../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group Application/AppFramework
    ../../../../../Demos/micokit/SiteWhere_Enjoy/AppFramework/: MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MICOAppDefine.h
  group Application/SiteWhere
    ../../../../../Demos/micokit/SiteWhere_Enjoy/SiteWhere/: BasicEvents.c custom.c double_conversion.c libemqtt.c localClient.c MiCOSiteWhere.c mqtt.c pb_decode.c pb_encode.c sitewhere.c sitewhere-arduino.pb.c
  group Application/User
    ../../../../../Demos/micokit/SiteWhere_Enjoy/User/: user_main.c user_config.h mico_config.h
  group include
    ../../../../../include/: MICO.h
  group Platform/Cortex-M4
    ../../../../../Platform/Cortex-M4/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/Drivers/MFiAuth
    ../../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors
    ../../../../../Platform/Drivers/sensor/BME280/: bme280.c bme280_user.c
    ../../../../../Platform/Drivers/sensor/DHT11/: DHT11.c
    ../../../../../Platform/Drivers/sensor/infrared_adc/: infrared_reflective.c
    ../../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c
  group Platform/Drivers/SPI_Flash
    ../../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/MCU
    ../../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/RVMDK
    ../../../../../Platform/MCU/STM32F4xx/RVMDK/: startup_stm32f4xx_RVMDK.s
  group Platform/MCU/STM32F4xx/wlan_bus_driver
    ../../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Platform/MCU/STM32F4xx/peripherals/Libraries
    ../../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/MCU/STM32F4xx/peripherals
    ../../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Library/protocols/fog_cloud
    ../../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a
  group Library/utilities
    ../../../../../libraries/utilities/: CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SocketUtils.c StringUtils.c URLUtils.c
  group Library/utilities/json_c
    ../../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group MICO/system
    ../../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
  group MICO/system/command_console
    ../../../../../MICO/system/command_console/: mico_cli.c
  group MICO/system/config_server
    ../../../../../MICO/system/config_server/: config_server.c config_server_menu.c
  group MICO/system/easylink
    ../../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
  group MICO/system/mdns
    ../../../../../MICO/system/mdns/: mico_mdns.c
  group MICO/system/tftp_ota
    ../../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group MICO/core
    ../../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a
  group Platform/Drivers/MiCOKit-EXT/drivers
    ../../../../../Platform/Drivers/display/VGM128064/: AsciiLib.c oled.c
    ../../../../../Platform/Drivers/keypad/gpio_button/: button.c
    ../../../../../Platform/Drivers/motor/dc_motor/: dc_motor.c
    ../../../../../Platform/Drivers/rgb_led/P9813/: hsb2rgb_led.c rgb_led.c
    ../../../../../Platform/Drivers/MiCOKit_EXT/: temp_hum_sensor.c
target MiCOKit-3165 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: as above
  output: SiteWhere_Enjoy.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG HSE_VALUE=26000000 MICOKIT_3165
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\AppFramework;..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\User;..\..\..\..\..\include;..\..\..\..\..\MICO\system;..\..\..\..\..\libraries\utilities;..\..\..\..\..\MICO\security;..\..\..\..\..\Board\MiCOKit-3165;..\..\..\..\..\Platform\include;..\..\..\..\..\Platform\Cortex-M4;..\..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\..\Platform\Drivers\MiCOKit_EXT;..\..\..\..\..\include\FogCloud;..\..\..\..\..\Demos\micokit\SiteWhere_Enjoy\SiteWhere;..\..\..\..\..\Platform\Drivers;..\..\..\..\..\Platform\Drivers\display;..\..\..\..\..\Platform\Drivers\rgb_led;..\..\..\..\..\Platform\Drivers\sensor
  asm misc: --cpreproc
  memory RVCT4: ROM 0x800c000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
